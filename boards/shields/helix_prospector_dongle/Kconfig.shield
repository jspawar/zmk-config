## boards/shields/helix_prospector_dongle/Kconfig.shield
```kconfig
config SHIELD_HELIX_PROSPECTOR_DONGLE
    def_bool $(shields_list_contains,helix_prospector_dongle)
```
